# IAR project N25Q256A_STM32L476G-EVAL.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32L4xx ST STM32L4xx
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: ..\..\Includes\CMSIS_Files; ..\..\Includes\Library_Files; ..\..\Includes\Loader_Files
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: N25Q256A_STM32L476G-EVAL.hex
  postbuild: cmd.exe /C copy "Debug\Exe\N25Q256A_STM32L476G-EVAL.out" "..\..\..\N25Q256A_STM32L476G-EVAL.stldr"
  ILINK.IlinkOutputFile: N25Q256A_STM32L476G-EVAL.out
  ILINK.IlinkIcfFile: Target.icf
  ILINK.IlinkExtraOptions: --no_remove
  ILINK.IlinkProgramEntryLabel: Init
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Loader
    ../../Sources/Loader_Files/: Dev_Inf.c Loader_Src.c
  group STM32l4xx
    ../../Sources/Library_Files/: stm32l4xx_gpio.c stm32l4xx_quadspi.c stm32l4xx_rcc.c stm32l4xx_syscfg.c
