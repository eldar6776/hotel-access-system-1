# IAR project Backup of N25Q256A_STM32L476G-EVAL.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32L4xx ST STM32L4xx
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32L4XX; __VECT_TAB_SRAM
  ICCARM.CCIncludePath2: C:\Program Files\STMicroelectronics\STM32 ST-LINK Utility\ST-LINK Utility\ExternalLoader\N25Q256A_Orca-EVAL\Includes\Library_Files; C:\Program Files\STMicroelectronics\STM32 ST-LINK Utility\ST-LINK Utility\ExternalLoader\N25Q256A_Orca-EVAL\Includes\Loader_Files
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: N25Q256A_EVAL.srec
  postbuild: cmd.exe /C copy "!L" "..\..\..\@L.stldr"
  ILINK.IlinkOutputFile: N25Q256A_EVAL.out
  ILINK.IlinkIcfFile: C:\Program Files\STMicroelectronics\STM32 ST-LINK Utility\ST-LINK Utility\ExternalLoader\N25Q256A_Orca-EVAL\Project\EWARM\Target.icf
  ILINK.IlinkProgramEntryLabel: Init
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Loader
    ../../Sources/Loader_Files/: Dev_Inf.c Loader_Src.c
  group STM32l4xx
    ../../Sources/Library_Files/: stm32l4xx_gpio.c stm32l4xx_quadspi.c stm32l4xx_rcc.c stm32l4xx_syscfg.c
