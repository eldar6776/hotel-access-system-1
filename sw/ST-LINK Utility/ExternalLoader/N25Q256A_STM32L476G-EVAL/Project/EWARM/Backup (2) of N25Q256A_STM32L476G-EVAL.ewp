# IAR project Backup (2) of N25Q256A_STM32L476G-EVAL.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  ICCARM.CCDefines: STM32L4xx; STM32L4XX
  ICCARM.CCIncludePath2: ..\..\Includes\Library_Files; ..\..\Includes\Loader_Files
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: N25Q256A_EVAL.hex
  ILINK.IlinkOutputFile: N25Q256A_EVAL.out
  ILINK.IlinkIcfFile: Target.icf
  ILINK.IlinkExtraOptions: --no_remove
  ILINK.IlinkProgramEntryLabel: Init
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  group Loader
    ../../Sources/Loader_Files/: Dev_Inf.c Loader_Src.c
  group STM32l4xx
    ../../Sources/Library_Files/: stm32l4xx_gpio.c stm32l4xx_quadspi.c stm32l4xx_rcc.c stm32l4xx_syscfg.c
