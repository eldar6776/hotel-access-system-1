# Keil uVision project M29W128GL_STM3210E-EVAL.uvproj, settings and files
target M29W128GL_STM3210E-EVAL (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: M29W128GL_STM3210E-EVAL
  AfterMake: cmd.exe /C copy "!L" "..\..\..\@L.stldr"
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_XL, USE_STDPERIPH_DRIVER
  c include: ..\..\Includes\Library_Files;..\..\Includes\Loader_Files
  scatter file: Target.lin
  link misc: --diag_suppress L6305
  group Loader
    ../../Sources/Loader_Files/: Dev_Inf.c Loader_Src.c
  group STM32F10x
    ../../Sources/Library_Files/: stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_rcc.c stm3210e_eval_fsmc_nor.c system_stm32f10x.c
