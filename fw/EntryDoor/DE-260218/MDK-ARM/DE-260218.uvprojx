# Keil uVision project DE-260218.uvprojx, settings and files
target DE-260218 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: DE-260218
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc;..\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --diag_suppress=L6329
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_crc.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_i2c.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_pcd.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal_spi_ex.c stm32f1xx_hal_uart.c stm32f1xx_ll_usb.c stm32f1xx_hal_pcd_ex.c
  group Middleware/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User
    ../Src/: stm32f1xx_hal_msp.c stm32f1xx_it.c main.c signal.c nrf24l01.c usb_device.c usbd_cdc_if.c usbd_conf.c usbd_desc.c
software components: CMSIS:CORE 5.1.1
