# Keil uVision project DE-160318.uvprojx, settings and files
target DE-160318 (6100001::V6.10.1::.\ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: DE-160318 +hex
  AfterMake: C:\Keil\ARM\ARMCC\bin\fromelf.exe --bin --output=DE-160318.bin F:\SkyDrive\OtvoreniProjekti\HotelSaplast\fw\RoomController\DE-160318\MDK-ARM\DE-160318\DE-160318.axf
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6Lto=1 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x3000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --diag_suppress=L6329
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_tim.c stm32f1xx_hal_spi.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_i2c.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_spi_ex.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_rcc.c stm32f1xx_hal_crc.c stm32f1xx_hal.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User
    ../Src/: stm32f1xx_hal_msp.c stm32f1xx_it.c main.c
software components: CMSIS:CORE 5.1.2
