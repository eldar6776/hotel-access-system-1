# Keil uVision project HCBL020318.uvprojx, settings and files
target HCBL020318 (6130001::V6.13.1::.\ARMCLANG)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: HCBL020318 +hex
  AfterMake: C:\Keil\ARM\ARMCC\bin\fromelf.exe --bin --output=HCBL.BIN Exe\HCBL020318.axf
  c flags: Optim=7 OneElfS=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: STM32F429_439xx,USE_STDPERIPH_DRIVER, USE_LCD,
  c include: ..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\FreeRTOS\include;..\Libraries\lwip-1.4.1\src\include;..\Libraries\lwip-1.4.1\src\include\ipv4;..\Libraries\lwip-1.4.1\src\include\lwip;..\Libraries\lwip-1.4.1\src\include\netif;..\Libraries\lwip-1.4.1\port\arch;..\Libraries\lwip-1.4.1\port\Standalone;..\Libraries\lwip-1.4.1\src\netif;..\User\ETH_driver;..\Application;..\Driver;..\User\TFTP_Server;..\User\FATFS;..\User\Http;..\Utilities\STM32_EVAL\Common;..\Demo;..\Libraries\STemWinLibrary532\inc;..\Libraries\STemWinLibrary532\Config;..\Application\Dsiplay;..\Libraries\Config
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Libraries/CMSIS
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f429_439xx.s
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Libraries/StdPeriph_Driver_v1.5.0
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_sdio.c stm32f4xx_fmc.c stm32f4xx_ltdc.c stm32f4xx_i2c.c stm32f4xx_dma.c stm32f4xx_dma2d.c
  group DEVICE_Driver
    ../Driver/: sdio_sd.c i2c_eeprom.c stm32f429i_lcd.c stm32f429i_sdram.c
  group FATFS
    ../User/FATFS/: ff.c
    ../User/TFTP_Server/: fatfs_drv.c
    ../Driver/: flash_if.c
  group Application
    ../Application/: main.c stm32f4xx_it.c
    ../Driver/: command.c
